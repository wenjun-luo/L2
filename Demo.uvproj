# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8411 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: 62605Demo +hex
  c flags: SizeSpeed=1
  c include: .\H;.\User;.\TKDriver\C
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
    ./c/: main.c BTM.c EX_Init.c IAP_Init.c IO_Init.c LCD_Init.c Multiplication_Division.c PWM_Init.c SSI_Init.c Timer_Init.c Uart_Init.c ADC_Init.c
  group User
    ./User/: TKDriver.C SC92F8X1X_HighSensitive_lib_T1_L_V2.2.0.LIB RingBuffer_C51.c project.c Radar.c BreatheLED.c
